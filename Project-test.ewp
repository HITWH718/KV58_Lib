# IAR project Project-test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CortexM7MPS2FVP Cortex-M7 MPS2 FVP
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: CPU_MKV58F1M0VLQ24; DEBUG; TWR_KV58F220M; TOWER; PRINTF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: App\inc; Board\inc; Chip\inc; Lib\CMSIS\inc; Chip\inc\iar; Lib\inc; utilities\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project-test.hex
  ILINK.IlinkOutputFile: Project-test.out
  ILINK.IlinkIcfFile: Prj\MKV58F1M0xxx24_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App
    App/src/: main.c
  group Board
    Board/src/: dma.c gpio.c led.c pit.c port.c uart.c
    Board/inc/: dma.h
  group Chip
    Chip/src/iar/: startup_MKV58F24.s system_MKV58F24.c
  group Lib
    Lib/src/: fsl_adc16.c fsl_aoi.c fsl_clock.c fsl_cmp.c fsl_common.c fsl_crc.c fsl_dac.c fsl_dmamux.c fsl_dspi.c fsl_dspi_edma.c fsl_edma.c fsl_enc.c fsl_enet.c fsl_ewm.c fsl_flexbus.c fsl_flexcan.c fsl_flexcan_edma.c fsl_ftfx_cache.c fsl_ftfx_controller.c fsl_ftfx_flash.c fsl_ftfx_flexnvm.c fsl_ftm.c fsl_gpio.c fsl_hsadc.c fsl_i2c.c fsl_i2c_edma.c fsl_llwu.c fsl_lptmr.c fsl_pdb.c fsl_pit.c fsl_pmc.c fsl_pwm.c fsl_rcm.c fsl_sim.c fsl_smc.c fsl_sysmpu.c fsl_trng.c fsl_uart.c fsl_uart_edma.c fsl_wdog.c fsl_xbara.c fsl_xbarb.c
