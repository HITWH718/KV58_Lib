<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\KV58_Lib.ewp</path>
    </project>
    <batchBuild />
</workspace>
