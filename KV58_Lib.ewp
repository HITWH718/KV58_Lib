# IAR project KV58_Lib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV58F1M0xxx24 NXP MKV58F1M0xxx24
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MKV58F1M0VLQ24; TWR_KV58F220M; TOWER; _DLIB_FILE_DESCRIPTOR; CPU_MKV58F1M0VLQ24_cm7; FSL_RTOS_FREE_RTOS; SDK_OS_FREE_RTOS; SDK_CORE_ID_CORE0; TWR_KV58F220M; PRINTF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: App\inc; Board\inc; Chip\inc; Sys\inc; Lib\CMSIS\inc; Chip\inc\iar; Lib\inc; utilities\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: KV58_Lib.hex
  ILINK.IlinkOutputFile: KV58_Lib.out
  ILINK.IlinkIcfFile: Prj\MKV58F1M0xxx24_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App
    App/src/: main.c
  group Chip
    Chip/src/iar/: startup.c startup_MKV58F24.s system_MKV58F24.c
  group Lib
    Lib/src/: adc.c dma.c flash.c ftm.c gpio.c iic.c iic_soft.c led.c lptmr.c pit.c port.c spi.c spi_soft.c systick.c uart.c
  group Sys
    Sys/src/: clock_config.c fsl_clock.c fsl_common.c fsl_ftfx_cache.c fsl_ftfx_controller.c fsl_ftfx_flash.c fsl_smc.c
    Sys/inc/: fsl_flash.h fsl_ftfx_adapter.h fsl_ftfx_features.h fsl_ftfx_utilities.h
